FILESEXTRAPATHS_prepend := "${THISDIR}/linux-yocto:"

SRC_URI_append_intel-corei7-64 = " file://0001-Docbook-media-Remove-extra-comma-from-10-bit-raw-bay.patch"
SRC_URI_append_intel-corei7-64 = " file://0002-media-v4l-Add-new-vectorised-raw-bayer-pixel-formats.patch"
SRC_URI_append_intel-corei7-64 = " file://0003-DocBook-media-Document-vector-raw-bayer-pixel-format.patch"
SRC_URI_append_intel-corei7-64 = " file://0004-media-v4l-Add-32-long-vector-YUV-format-define.patch"
SRC_URI_append_intel-corei7-64 = " file://0005-DocBook-v4l-Add-documentation-for-YUYV420_V32-pixel-.patch"
SRC_URI_append_intel-corei7-64 = " file://0006-mm-EXPORT_SYMBOL_GPL-find_vm_area.patch"
SRC_URI_append_intel-corei7-64 = " file://0007-v4l-Add-frame-end-event.patch"
SRC_URI_append_intel-corei7-64 = " file://0008-HACK-Temporary-format-definitions.patch"
SRC_URI_append_intel-corei7-64 = " file://0009-Add-number-of-mipi-lanes-control.patch"
SRC_URI_append_intel-corei7-64 = " file://0010-v4l-subdev-Add-support-for-sub-streams.patch"
SRC_URI_append_intel-corei7-64 = " file://0011-v4l-Mark-setting-frame-descriptors-deprecated.patch"
SRC_URI_append_intel-corei7-64 = " file://0012-v4l-Add-sub-stream-mask-id-for-buffer-type.patch"
SRC_URI_append_intel-corei7-64 = " file://0013-v4l-Add-bus-type-to-frame-descriptors.patch"
SRC_URI_append_intel-corei7-64 = " file://0014-v4l-Extend-struct-v4l2_mbus_frame_desc_entry.patch"
SRC_URI_append_intel-corei7-64 = " file://0015-v4l-Add-information-for-2D-DMA-to-the-frame-descript.patch"
SRC_URI_append_intel-corei7-64 = " file://0016-WDR-mode-hack.patch"
SRC_URI_append_intel-corei7-64 = " file://0018-v4l-Correct-the-ordering-of-LSBs-of-the-10-bit-raw-p.patch"
SRC_URI_append_intel-corei7-64 = " file://0019-v4l-Add-packed-Bayer-raw12-pixel-formats.patch"
SRC_URI_append_intel-corei7-64 = " file://0001-media-Determine-early-whether-an-IOCTL-is-supported.patch"
SRC_URI_append_intel-corei7-64 = " file://0002-media-Add-flags-to-tell-whether-to-take-graph-mutex-.patch"
SRC_URI_append_intel-corei7-64 = " file://0003-media-Unify-IOCTL-handler-calling.patch"
SRC_URI_append_intel-corei7-64 = " file://0004-media-Refactor-copying-IOCTL-arguments-from-and-to-u.patch"
SRC_URI_append_intel-corei7-64 = " file://0005-media-Support-variable-size-IOCTL-arguments.patch"
SRC_URI_append_intel-corei7-64 = " file://0006-media-Move-media_device-link_notify-operation-to-an-.patch"
SRC_URI_append_intel-corei7-64 = " file://0007-media-Add-per-file-handle-data-support.patch"
SRC_URI_append_intel-corei7-64 = " file://0008-media-Add-request-API.patch"
SRC_URI_append_intel-corei7-64 = " file://0009-media-Add-media-device-request-state.patch"
SRC_URI_append_intel-corei7-64 = " file://0010-media-Prevent-queueing-queued-requests.patch"
SRC_URI_append_intel-corei7-64 = " file://0011-media-Only-requests-in-IDLE-state-may-be-deleted.patch"
SRC_URI_append_intel-corei7-64 = " file://0012-media-Add-media_device_request_complete-to-mark-requ.patch"
SRC_URI_append_intel-corei7-64 = " file://0013-videodev2.h-Add-request-field-to-v4l2_buffer.patch"
SRC_URI_append_intel-corei7-64 = " file://0014-vb2-Add-allow_requests-flag.patch"
SRC_URI_append_intel-corei7-64 = " file://0015-media-Add-MEDIA_IOC_DQEVENT.patch"
SRC_URI_append_intel-corei7-64 = " file://0016-media-Make-events-on-request-completion-optional-dis.patch"
SRC_URI_append_intel-corei7-64 = " file://0017-media-Add-poll-support.patch"
SRC_URI_append_intel-corei7-64 = " file://0001-media-entity-Add-has_route-entity-operation.patch"
SRC_URI_append_intel-corei7-64 = " file://0002-media-entity-Add-media_entity_has_route-function.patch"
SRC_URI_append_intel-corei7-64 = " file://0003-media-entity-Use-routing-information-during-graph-tr.patch"
SRC_URI_append_intel-corei7-64 = " file://0004-v4l-subdev-Add-GS-_ROUTING-subdev-ioctls-and-operati.patch"
SRC_URI_append_intel-corei7-64 = " file://0005-v4l-Take-routing-information-into-account-in-link-va.patch"
SRC_URI_append_intel-corei7-64 = " file://0006-v4l-subdev-Add-source-route-flag.patch"
SRC_URI_append_intel-corei7-64 = " file://0007-v4l-for-multiplex-pad-add-routing-informaion-in-link.patch"
SRC_URI_append_intel-corei7-64 = " file://0008-Revert-v4l-subdev-Add-support-for-sub-streams.patch"
SRC_URI_append_intel-corei7-64 = " file://0009-v4l-subdev-Add-support-for-sub-streams.patch"
SRC_URI_append_intel-corei7-64 = " file://0010-media-entity-graph-walk-starting-from-pad.patch"
SRC_URI_append_intel-corei7-64 = " file://0011-media-Increase-number-of-max-media-entities.patch"
SRC_URI_append_intel-corei7-64 = " file://0001-media-Add-1X14-14-bit-raw-bayer-media-bus-code-defin.patch"
SRC_URI_append_intel-corei7-64 = " file://0001-v4l-Packed-Bayer-raw12-pixel-formats.patch"
SRC_URI_append_intel-corei7-64 = " file://0001-v4l-Add-14-bit-raw-bayer-pixel-format-definitions.patch"
SRC_URI_append_intel-corei7-64 = " file://0002-v4l-Add-packed-Bayer-raw14-pixel-formats.patch"
SRC_URI_append_intel-corei7-64 = " file://0001-Add-Kconfig-for-Intel-IPU4-driver.patch"
SRC_URI_append_intel-corei7-64 = " file://0001-media-Increase-number-of-max-media-entities-to-256.patch"
SRC_URI_append_intel-corei7-64 = " file://ipu4-driver.cfg"

